# Keil uVision project K870T.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH555 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(48000000)
  output: K870T +hex
  c flags: Optimize=9
  group Source Group 1
    ./: Debug.C MATRIX.c main.c USB_HANDLER.c
